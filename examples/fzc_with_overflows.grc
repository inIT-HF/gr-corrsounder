<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>overflowgenerator</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>display_points</value></param>
<param><key>value</key><value>overflowrate*3+seq_len+1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>noverflows</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>overflowrate</value></param>
<param><key>value</key><value>401</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>seq_len</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>seq_len</value></param>
<param><key>value</key><value>255</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>snr</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>SNR (dB)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-10</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>10</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0</value></param>
<param><key>m</key><value>overflowrate</value></param>
<param><key>n</key><value>overflowrate+noverflows</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_tags_strobe</key>
<param><key>id</key><value>blocks_tags_strobe_0</value></param>
<param><key>key</key><value>pmt.intern("overflows")</value></param>
<param><key>nsamps</key><value>overflowrate</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>value</key><value>pmt.to_pmt(noverflows)</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>epsilon</key><value>1.0</value></param>
<param><key>freq_offset</key><value>0.0</value></param>
<param><key>noise_voltage</key><value>pow(10,(snr/20.))</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>[1.0]</value></param>
</block>
<block>
<key>corrsounder_fzc_correlator_c</key>
<param><key>id</key><value>corrsounder_fzc_correlator_c_0</value></param>
<param><key>q</key><value>7</value></param>
<param><key>n_fzc</key><value>seq_len</value></param>
</block>
<block>
<key>corrsounder_fzc_source_c</key>
<param><key>id</key><value>corrsounder_fzc_source_c_0</value></param>
<param><key>q</key><value>7</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>n_fzc</key><value>seq_len</value></param>
</block>
<block>
<key>corrsounder_skip_overflow</key>
<param><key>id</key><value>corrsounder_skip_overflow_0</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sequence_length</key><value>seq_len</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>alpha1</key><value>0.3</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>alpha2</key><value>0.3</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>display_points</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ylabel</key><value>Impulse response</value></param>
<param><key>ymax</key><value>2</value></param>
<param><key>ymin</key><value>-2</value></param>
</block>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>corrsounder_skip_overflow_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tags_strobe_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>corrsounder_fzc_correlator_c_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>corrsounder_fzc_source_c_0</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>corrsounder_skip_overflow_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>corrsounder_skip_overflow_0</source_block_id><sink_block_id>corrsounder_fzc_correlator_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
