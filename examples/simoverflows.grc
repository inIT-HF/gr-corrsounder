<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>simoverflows</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data</value></param>
<param><key>value</key><value>np.arange(0, overflow_rate*2)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_with_overflows</value></param>
<param><key>value</key><value>data[np.mod(data, overflow_rate) &gt; 0]</value></param>
</block>
<block>
<key>variable_tag_object</key>
<param><key>id</key><value>overflow0</value></param>
<param><key>key</key><value>pmt.intern("overflows")</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>src</key><value>pmt.intern("src0")</value></param>
<param><key>value</key><value>pmt.from_long(1)</value></param>
</block>
<block>
<key>variable_tag_object</key>
<param><key>id</key><value>overflow1</value></param>
<param><key>key</key><value>pmt.intern("overflows")</value></param>
<param><key>offset</key><value>overflow_rate-1</value></param>
<param><key>src</key><value>pmt.intern("src0")</value></param>
<param><key>value</key><value>pmt.from_long(1)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>overflow_rate</value></param>
<param><key>value</key><value>11</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_vector_sink_x</key>
<param><key>id</key><value>dst</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>corrsounder_skip_overflow</key>
<param><key>id</key><value>dut</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sequence_length</key><value>5</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>src</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>tags</key><value>[overflow0, overflow1]</value></param>
<param><key>vlen</key><value>overflow_rate-1</value></param>
<param><key>vector</key><value>data_with_overflows</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>v2s</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>overflow_rate-1</value></param>
</block>
<connection><source_block_id>dut</source_block_id><sink_block_id>dst</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>src</source_block_id><sink_block_id>v2s</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>v2s</source_block_id><sink_block_id>dut</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
