<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>post_processing_correlation</value></param>
<param><key>author</key><value>Niels Fliedner</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>5.8e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fzc_seq_auto</value></param>
<param><key>value</key><value>[(pow((-1),(seq_param*n))*np.exp((1j*np.pi*seq_param*pow(n,2))/(seq_len))) for n in range(1, (seq_len+1))]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>200e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>seq_len</value></param>
<param><key>value</key><value>255</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>seq_param</value></param>
<param><key>value</key><value>7</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>snapshot_len</value></param>
<param><key>value</key><value>seq_len*3</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_file_meta_source</key>
<param><key>id</key><value>blocks_file_meta_source_0</value></param>
<param><key>detached</key><value>True</value></param>
<param><key>file</key><value>/home/hf/workspace/measurement-robotarm3/2017-06-08-robotarm-5_8GHz-150MHz-snapshot_approach.dat</value></param>
<param><key>hdr_file</key><value>/home/hf/workspace/measurement-robotarm3/2017-06-08-robotarm-5_8GHz-150MHz-snapshot_approach.dat.hdr</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vlen</key><value>snapshot_len</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/hf/workspace/measurement-robotarm3/2017-06-08-robotarm-5_8GHz-150MHz-snapshot_approach-corr.dat</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0_0</value></param>
<param><key>k</key><value>0</value></param>
<param><key>n</key><value>20</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>snapshot_len</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>seq_len</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>seq_len</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>seq_len</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>samples_per_second</key><value>2550</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>snapshot_len</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>np.conj(fzc_seq_auto[::-1])</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>gapfiller_0</value></param>
<param><key>_source_code</key><value>#!/usr/bin/env python
# -*- coding: utf-8 -*-
# 
# Copyright 2016 &lt;+YOU OR YOUR COMPANY+&gt;.
# 
# This is free software; you can redistribute it and/or modify
# it under the terms of the GNU General Public License as published by
# the Free Software Foundation; either version 3, or (at your option)
# any later version.
# 
# This software is distributed in the hope that it will be useful,
# but WITHOUT ANY WARRANTY; without even the implied warranty of
# MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
# GNU General Public License for more details.
# 
# You should have received a copy of the GNU General Public License
# along with this software; see the file COPYING.  If not, write to
# the Free Software Foundation, Inc., 51 Franklin Street,
# Boston, MA 02110-1301, USA.
# 

import numpy as np
from gnuradio import gr
import pmt
import cPickle

class gapfiller(gr.sync_block):
    """
    docstring for block gapfiller
    """
    def __init__(self, snapshoot_len = 255, pickle_file = 'gapfiller_resample.pickle'):
        gr.sync_block.__init__(self,
            name="Gapfiller",
            in_sig=[(np.complex64, snapshoot_len)],
            out_sig=[(np.complex64, snapshoot_len)])
        
        self.rx_rate = None
        self.offset_prev = 0
        self.rx_time_prev_secs = 0
        self.rx_time_prev_frac = 0.0
        
        self.snapshoot_len = snapshoot_len

        # To be pickled...
        self.pickle_file = pickle_file
        self.rx_time_prev_secs_list = []
        self.rx_time_prev_frac_list = []
        self.offset_list = []
        

    def work(self, input_items, output_items):
        in0 = input_items[0][0]
        out = output_items[0][0]
        
        # Get reception rate once
        if self.rx_rate == None:
            rx_rate_tags = self.get_tags_in_window(0, 0, 1, pmt.string_to_symbol("rx_rate"))
            self.rx_rate = pmt.to_double(rx_rate_tags[0].value)
        
        rx_time_tags = self.get_tags_in_window(0, 0, 1, pmt.string_to_symbol("rx_time"))
        shift = 0
        if len(rx_time_tags) &gt; 0:
            tt = rx_time_tags[0]
            
            # Compute number of zeros to add
            self.rx_time_secs = pmt.to_uint64(pmt.tuple_ref(tt.value, 0))
            self.rx_time_frac = pmt.to_double(pmt.tuple_ref(tt.value, 1))
            self.offset       = tt.offset

            diff_offset_real  = ((self.rx_time_secs-self.rx_time_prev_secs)+(self.rx_time_frac-self.rx_time_prev_frac))
            
            if self.offset &gt;= 1600/3 and self.offset &lt; 1620/3:
                diff_offset = (self.offset - self.offset_prev)
                zeros = diff_offset_real - diff_offset
                shift = np.mod(round(zeros), self.snapshoot_len)
                print diff_offset_real

            # To be pickled...
            self.offset_list.append(self.offset)
            self.rx_time_prev_secs_list.append(self.rx_time_secs)
            self.rx_time_prev_frac_list.append(self.rx_time_frac)    
 
            #save previous value
            self.offset_prev = self.offset
            self.rx_time_prev_secs = self.rx_time_secs
            self.rx_time_prev_frac = self.rx_time_frac      
            
            
      
        #output_items[0][0][:] = np.roll(np.input_items[0][0], shift, axis=0)
        output_items[0][0][:] = input_items[0][0]
        print self.offset

        return 1
        
    def stop(self):
        with open(self.pickle_file, "wb") as output_file:
            cPickle.dump(
                {'offset_list': self.offset_list, 
                'rx_time_prev_secs_list': self.rx_time_prev_secs_list, 
                'rx_time_prev_frac_list': self.rx_time_prev_frac_list,
                'rx_rate': self.rx_rate}, 
                output_file)
        return True




</value></param>
<param><key>pickle_file</key><value>'gapfiller_resample.pickle'</value></param>
<param><key>snapshoot_len</key><value>seq_len</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>qtgui_time_raster_sink_x</key>
<param><key>id</key><value>qtgui_time_raster_sink_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>zmax</key><value>0</value></param>
<param><key>zmin</key><value>-60</value></param>
<param><key>ncols</key><value>255</value></param>
<param><key>nrows</key><value>61</value></param>
<param><key>samp_rate</key><value>samp_rate*3./4.</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>-1</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>update_time</key><value>0.01</value></param>
<param><key>vlen</key><value>seq_len</value></param>
<param><key>x_start</key><value>0</value></param>
<param><key>x_step</key><value>1.0</value></param>
<param><key>ymax</key><value>0</value></param>
<param><key>ymin</key><value>-70</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>4</value></param>
<param><key>interp</key><value>3</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>blocks_nlog10_ff_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0_0</source_block_id><sink_block_id>qtgui_time_raster_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_1</source_block_id><sink_block_id>gapfiller_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>fft_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gapfiller_0</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_stream_to_vector_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
